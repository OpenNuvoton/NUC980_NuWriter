# Keil uVision project NuWriterFW_64MB.uvproj, settings and files
target NuWriterFW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NuWriterFW_64MB
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: header_64MB.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: TURBOWRITER64=1
  c include: .\driver\Include
  memory RVCT1: ROM 0x3f00000 size 0x100000
  memory RVCT6: RAM 0x8000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\source\scat_c_64.scf
  link misc: --entry 0x03F00040
  group Source
    ./source/: usbd.c standalone.c sm.c spiflash.c main.c parse.c sdglue.c filesystem.c wb_init_64.s exesdramdtb.s spinandflash.c sd.c
  group Libraries
    ./driver/Source/: cache.c retraget.c sys.c etimer.c gpio.c qspi.c
