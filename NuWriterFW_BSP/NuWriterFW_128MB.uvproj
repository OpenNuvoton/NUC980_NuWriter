# Keil uVision project NuWriterFW_128MB.uvproj, settings and files
target NuWriterFW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NuWriterFW_128MB
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: header_128MB.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: TURBOWRITER128=1
  c include: .\driver\Include
  memory RVCT1: ROM 0x7f00000 size 0x100000
  memory RVCT6: RAM 0x8000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\source\scat_c_128.scf
  link misc: --entry 0x07F00040
  group Source
    ./source/: usbd.c standalone.c sm.c spiflash.c main.c parse.c sd.c sdglue.c filesystem.c exesdramdtb.s wb_init_128.s spinandflash.c
  group Libraries
    ./driver/Source/: cache.c retraget.c sys.c etimer.c qspi.c gpio.c
