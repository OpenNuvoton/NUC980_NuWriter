# Keil uVision project NuWriterFW_16MB.uvproj, settings and files
target NuWriterFW (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NuWriterFW_16MB
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\@L.bin"
  AfterMake: header_16MB.bat
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: TURBOWRITER16=1
  c include: .\driver\Include
  memory RVCT1: ROM 0xf00000 size 0x100000
  memory RVCT6: RAM 0x8000 size 0x80000
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\source\scat_c_16.scf
  link misc: --entry 0x0F00040
  group Source
    ./source/: usbd.c sm.c spiflash.c parse.c sd.c sdglue.c filesystem.c wb_init_16.s main.c exesdramdtb.s standalone.c spinandflash.c
  group Libraries
    ./driver/Source/: cache.c retraget.c sys.c etimer.c gpio.c qspi.c
